## boards/shields/Saru48WPlus/Kconfig.defconfig
```kconfig
if SHIELD_SARU48WPLUS

config ZMK_KEYBOARD_NAME
    default "Saru48WPlus"

endif
```
